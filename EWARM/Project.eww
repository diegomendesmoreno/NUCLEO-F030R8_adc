<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NUCLEO-F030R8_adc.ewp</path>
  </project>
  <batchBuild />
</workspace>
